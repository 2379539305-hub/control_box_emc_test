# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33LC04X FMSH
  pack: FMSH.FM33LC0XX_DFP.3.0.4
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf --bin -o ".\bin_file\Template.bin" ".\Objects\Template.axf"
  AfterMake: py ".\merge_bin.py"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=550,177
  c include: ..\Main;..\System;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\Drivers\MF-config\Inc;..\HardWareDriver\driver_inc;..\FunctionalModul\modul_a7105;..\FunctionalModul\modul_dropchk;..\FunctionalModul\modul_fan;..\FunctionalModul\modul_light;..\FunctionalModul\modul_motor;..\FunctionalModul\modul_musicmsgr;..\FunctionalModul\modul_ttlbus;..\Application\app_ble;..\Application\app_comm;..\Application\app_config;..\Application\app_fan;..\Application\app_heat;..\Application\app_light;..\Application\app_linbus;..\Application\app_motor;..\Application\app_msgr;..\Application\app_music;..\Application\app_rtc;..\Application\app_save;..\Application\app_ttlbus;..\Application\app_vita;..\Application\app_mesh;..\FunctionalModul\modul_key;..\Application\app_backhual;..\FunctionalModul\modul_adc_position;..\Drivers\FM33LC0xx_FL_Driver\Inc;..\Application\app_ota
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Main
    ../Main/: main.c iwdg.c
  group System
    ../System/: delay.c sys_it_callback.c system.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Drivers/MF-config/Src/: mf_config.c
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lc0xx.s
  group Application
    ../Application/app_ble/: app_ble.c
    ../Application/app_comm/: app_comm.c
    ../Application/app_config/: app_config.c
    ../Application/app_light/: app_light.c
    ../Application/app_linbus/: app_linbus.c
    ../Application/app_motor/: app_motor.c
    ../Application/app_msgr/: app_msgr.c
    ../Application/app_music/: app_music.c
    ../Application/app_rtc/: app_rtc.c
    ../Application/app_save/: app_save.c
    ../Application/app_ttlbus/: app_ttlbus.c
    ../Application/app_vita/: app_vita.c
    ../Application/app_backhual/: app_backhual.c
    ../Application/app_heat/: app_heat.c
    ../Application/app_fan/: app_fan.c
    ../Application/app_ota/: app_ota.c
    ../Application/app_mesh/: app_mesh.c
  group FunctionalModul
    ../FunctionalModul/modul_dropchk/: modul_dropchk.c
    ../FunctionalModul/modul_motor/: modul_motor.c
    ../FunctionalModul/modul_a7105/: modul_a7105.c
    ../FunctionalModul/modul_key/: modul_key.c
    ../FunctionalModul/modul_light/: modul_light.c
    ../FunctionalModul/modul_musicmsgr/: modul_musicmsgr.c
    ../FunctionalModul/modul_ttlbus/: modul_ttlbus.c
    ../FunctionalModul/modul_fan/: modul_fan.c
    ../FunctionalModul/modul_adc_position/: modul_adc_position.o
  group HardWareDriver
    ../HardWareDriver/driver_src/: driver_a7105.c driver_adc.c driver_beep.c driver_ble.c driver_dropchk.c driver_droppwr.c driver_eeprom.c driver_key.c driver_led.c driver_motor.c driver_uart.c driver_periph.c driver_rtc.c driver_timer.c
  group FM_Driver
    ../Drivers/FM33LC0xx_FL_Driver/Src/: fm33lc0xx_fl.c fm33lc0xx_fl_adc.c fm33lc0xx_fl_aes.c fm33lc0xx_fl_atim.c fm33lc0xx_fl_bstim32.c fm33lc0xx_fl_comp.c fm33lc0xx_fl_crc.c fm33lc0xx_fl_divas.c fm33lc0xx_fl_dma.c fm33lc0xx_fl_exti.c fm33lc0xx_fl_flash.c fm33lc0xx_fl_gpio.c fm33lc0xx_fl_gptim.c fm33lc0xx_fl_i2c.c fm33lc0xx_fl_iwdt.c fm33lc0xx_fl_lcd.c fm33lc0xx_fl_lptim32.c fm33lc0xx_fl_lpuart.c fm33lc0xx_fl_opa.c fm33lc0xx_fl_pmu.c fm33lc0xx_fl_rcc.c fm33lc0xx_fl_rng.c fm33lc0xx_fl_rtc.c fm33lc0xx_fl_spi.c fm33lc0xx_fl_svd.c fm33lc0xx_fl_u7816.c fm33lc0xx_fl_uart.c fm33lc0xx_fl_wwdt.c
